# Keil uVision project official-05-judge.uvprojx, settings and files
target official-05-judge (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.20.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: official-05-judge
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\APP;.\CSL;.\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM181_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
    ./APP/: delay.c IO.c judge.c pid.c send.c timer.c uart1.c uart2.c up.c adc.c measure.c driver.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
  group CSL\StdPD
    ./CSL/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cache.c SWM181_can.c SWM181_cmp.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_exti.c SWM181_flash.c SWM181_gpio.c SWM181_i2c.c SWM181_irqmux.c SWM181_port.c SWM181_pwm.c SWM181_sdadc.c SWM181_slcd.c SWM181_sleep.c SWM181_spi.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c
